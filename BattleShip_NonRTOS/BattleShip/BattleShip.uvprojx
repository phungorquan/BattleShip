# Keil uVision project BattleShip.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC131SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IROM(0x00000000,0x11000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: BattleShip
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\NUC131BSP_v3.00.003\Library\Device\Nuvoton\NUC131\Include;..\NUC131BSP_v3.00.003\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: main.c
  group NUC_StdDrv
    ../NUC131BSP_v3.00.003/Library/StdDriver/src/: clk.c gpio.c sys.c uart.c spi.c
  group LCD
    ./: LCDST7920.c BattleMap.c
  group Ethernet
    ./: ip_arp_udp_tcp.c ENC28J60.C
software components: CMSIS:CORE 5.1.2, Device:Startup 0.00.001
