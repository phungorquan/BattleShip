# Keil uVision project BattleShip_RTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC131SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IROM(0x00000000,0x11000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: FreeRTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\NUC131BSP_v3.00.003\Library\Device\Nuvoton\NUC131\Include;.\FreeRTOSv10.2.1\FreeRTOS\Source\include;.\FreeRTOSv10.2.1\FreeRTOS\Source\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group FreeRTOS
    ./FreeRTOSv10.2.1/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ./FreeRTOSv10.2.1/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./FreeRTOSv10.2.1/FreeRTOS/Source/: timers.c croutine.c event_groups.c list.c queue.c tasks.c
  group NUC131_Stdlib
    ../NUC131BSP_v3.00.003/Library/StdDriver/src/: clk.c gpio.c spi.c sys.c timer.c uart.c
  group User
    ./: main.c
  group LCD
    ./: BattleMap.c LCDST7920.c
  group W5500
    ./: socket.c w5500.c wizchip_conf.c
software components: CMSIS:CORE 5.1.2, Device:Startup 0.00.001
